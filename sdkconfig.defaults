## sdkconfig.defaults
```kconfig
CONFIG_ESP32_SPIRAM_SUPPORT=n
CONFIG_ESP_MAIN_TASK_STACK_SIZE=5000
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=n
CONFIG_ESPTOOLPY_FLASHSIZE="4MB"
```
